# SPDX-License-Identifier: MIT

# ForgeFIRM image manifest: source fingerprint of the hardware library
# (forgefirm-manifest.bbclass in this layer).
inherit forgefirm-manifest
