# SPDX-License-Identifier: MIT

# ForgeFIRM image manifest: source fingerprint of the cloud-mode service
# layer (forgefirm-manifest.bbclass in this layer).
inherit forgefirm-manifest
